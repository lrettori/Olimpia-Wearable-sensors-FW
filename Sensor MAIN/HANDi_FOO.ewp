# IAR project HANDi_FOO.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; App; App\inc; board\; LED\inc\; LED\src\; BLE_Lib\inc\; BLE_Lib\src\; ..\library\CMSIS\Core\CM3\; ..\library\STM32F10x_StdPeriph_Driver\inc\; SysConfig\inc; GUI_LAYER\inc; GUI_LAYER\src; GUI_LAYER\FCAL_FLASH_Lib\inc; GUI_LAYER\FCAL_FLASH_Lib\src; GUI_LAYER\EKF_Lib\inc; GUI_LAYER\EKF_Lib\src; Sensor_Lib\LSM9DS1\inc; Sensor_Lib\LSM9DS1\src; Sensor_Lib\SensorConfig\inc; VirCOM\USB\Class\inc; VirCOM\USB\Class\src; VirCOM\USB\Config\inc; VirCOM\USB\Core\inc; VirCOM\USB\Core\src; VirCOM\USB\HW\inc; VirCOM\USB\HW\src; VirCOM\USB\inc; VirCOM\USB\src; Vectors\inc; Vectors\src; VirCOM\UART\inc; VirCOM\UART\src; E:\Archivio\Università\Post-Doc\OLIMPIA\Firmware development\Olimpia Former Firmware\OLIMPIA - FOOT (2.4LP)\library\STM32F10x_StdPeriph_Driver\inc; E:\Archivio\Università\Post-Doc\OLIMPIA\Firmware development\Olimpia Former Firmware\OLIMPIA - FOOT (2.4LP)\library\STM32F10x_StdPeriph_Driver\src; Libraries\LED\inc; Libraries\LED\src; Libraries\LSM9DS1\inc; Libraries\LSM9DS1\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HANDi_FOO.srec
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config\STM32F10x_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; App; App\inc; board; GUI_LAYER\inc; GUI_LAYER\src; GUI_LAYER\FCAL_FLASH_Lib\inc; GUI_LAYER\FCAL_FLASH_Lib\src; GUI_LAYER\EKF_Lib\inc; GUI_LAYER\EKF_Lib\src; VirCOM\USB\Class\inc; VirCOM\USB\Class\src; VirCOM\USB\Config\inc; VirCOM\USB\Core\inc; VirCOM\USB\Core\src; VirCOM\USB\HW\inc; VirCOM\USB\HW\src; VirCOM\USB\inc; VirCOM\USB\src; VirCOM\UART\inc; VirCOM\UART\src; VirCOM\USB\Class\src; Libraries\LSM9DS1\inc; Libraries\LSM9DS1\src; Libraries\STM32F10x\STM32F10x_SP_Driver\inc; Libraries\STM32F10x\STM32F10x_SP_Driver\src; Libraries\STM32F10x\CMSIS; Libraries\STM32F10x\CMSIS\startup\iar
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: HANDi_FOO.hex
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; board\; App\inc; App; config; Libraries\LED\inc; Libraries\LED\src; Libraries\LSM9DS1\inc; Libraries\LSM9DS1\src; Libraries\STM32F10x\STM32F10x_SP_Driver\inc; Libraries\STM32F10x\STM32F10x_SP_Driver\src; Libraries\STM32F10x\CMSIS; Libraries\STM32F10x\CMSIS\startup\iar
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  group App
    App/: main.c stm32f10x_it.c
  group GUI_LAYER
    GUI_LAYER/src/: GUI_Layer.c
  group GUI_LAYER/EKF_Lib
    GUI_LAYER/EKF_Lib/src/: EKF_Lib.c
  group GUI_LAYER/FCAL_FLASH_Lib
    GUI_LAYER/FCAL_FLASH_Lib/src/: FCAL_STORAGE.c
  group Libraries/LSM9DS1
    Libraries/LSM9DS1/src/: LSM9DS1.c
  group Libraries/STM32F10x/CMSIS
    Libraries/STM32F10x/CMSIS/startup/iar/: startup_stm32f10x_md.s
    Libraries/STM32F10x/CMSIS/: system_stm32f10x.c
  group Libraries/STM32F10x/STM32F10x_SP_Drivers
    Libraries/STM32F10x/STM32F10x_SP_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Other
    ./: readme.txt
    config/: STM32F10x_FLASH.icf STM32F10x_RAM.icf
