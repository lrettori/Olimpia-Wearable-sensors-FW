# IAR project HANDi_FIN.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; board\; ..\library\CMSIS\Core\CM3\; ..\library\STM32F10x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config\STM32F10x_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; board\; SysConfig\inc; GUI_LAYER\inc; GUI_LAYER\EKF_Lib\inc; GUI_LAYER\FCAL_FLASH_Lib\inc; App\inc; Libraries\STM32F10x\STM32F10x_SP_Driver\inc; Libraries\STM32F10x\STM32F10x_SP_Driver\src; Libraries\STM32F10x\CMSIS; Libraries\STM32F10x\CMSIS\startup\iar; Libraries\LSM9DS1\inc; Libraries\LSM9DS1\src
  OBJCOPY.OOCOutputFile: HANDi_FIN.hex
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  group App
    App/: main.c stm32f10x_it.c
  group Libraries/LSM9DS1
    Libraries/LSM9DS1/src/: LSM9DS1.c
  group Libraries/STM32F10x/CMSIS
    Libraries/STM32F10x/CMSIS/startup/iar/: startup_stm32f10x_md.s
    Libraries/STM32F10x/CMSIS/: system_stm32f10x.c
  group Libraries/STM32F10x/STM32F10x_SP_Drivers
    Libraries/STM32F10x/STM32F10x_SP_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Other
    ./: readme.txt
    config/: STM32F10x_FLASH.icf STM32F10x_RAM.icf
